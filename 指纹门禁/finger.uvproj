# Keil uVision project finger.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: finger +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\IIC;.\OLED;.\JIDIANQI;.\KEY;.\UART;.\AS608;.\USER
  group USER
    ./: STARTUP.A51
    ./USER/: main.c Operate.c
  group OLED
    ./OLED/: Font.c OLED.c OLED_IIC.c
  group IIC
    ./IIC/: IIC.c
  group AS608
    ./AS608/: AS608.c
    ./UART/: Uart.c
  group KEY
    ./KEY/: Key.c
    ./JIDIANQI/: JIDIANQI.c
